# IAR project PP.ewp, settings and files
configuration PP Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F415RG ST STM32F415RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F415xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: PP Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Drivers
    ./: 
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c
  group Drivers/CMSIS
    ./: 
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Application
    ./: 
  group Application/User
    ./: 
    ../../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c stm32f4xx_it.c
  group Application/EWARM
    ./: 
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s startup_stm32f415xx.s
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
